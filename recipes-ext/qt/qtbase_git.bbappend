PACKAGECONFIG:remove = " xcb tests examples"

